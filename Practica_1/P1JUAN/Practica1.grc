options:
  parameters:
    author: labcom
    generate_options: qt_gui
    id: Practica1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Acumulacion
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      class blk (gr. sync_block ):
        def __init__ ( self ) :
            gr. sync_block . __init__(
                self ,
                name ='e_Acum ',
                in_sig =[ np. float32 ],
                out_sig =[ np. float32 ]
             )
        def work (self , input_items , output_items ):
              x = input_items [0] 
              y0 = output_items [0] 
              y0 [:] = np. cumsum (x)
              return len (y)
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (2, 4, -7)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [Acumulacion, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', Acumulacion, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
